## config/boards/shields/cozmok/Kconfig.defconfig
```kconfig
if SHIELD_COZMOK
  config ZMK_KEYBOARD_NAME
  default "cozmok"
endif

config SPI
    default y
```
